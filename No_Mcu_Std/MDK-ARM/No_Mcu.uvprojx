# Keil uVision project No_Mcu.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: No_Mcu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Core\Inc;..\Drivers\STM32F10x_StdPeriph_Driver\inc;..\Drivers\CMSIS;..\MDK-ARM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/Core
    ../Core/Src/: main.c stm32f10x_it.c adc.c gpio.c usart.c No_Mcu_Ganv_Grayscale_Sensor.c delay.c Motor.c PWM.c PID.c MyConfig.c encoder.c tim3.c
    ../Core/Inc/: PID.h MyConfig.h encoder.h tim3.h
    ./: LED.c LED.h sys.c sys.h OLED.c OLED.h OLED_Font.h Infrared.c Infrared.h Tim1.c Tim1.h key.c key.h
  group Application/Stdperiph
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Drivers/CMSIS/: core_cm3.c system_stm32f10x.c
  group Starup
    ../Drivers/CMSIS/: startup_stm32f10x_md.s
